File: tests/sample_project/sample.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: fix: edited sample projects
Other:
- moved on the sheet: C1
